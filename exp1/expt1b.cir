******************************************************************************
*          Electronic circuit simulation file generated by gSpiceUI          *
*                        Version 1.2.36 (2018-11-16)                         *
******************************************************************************

* DIODE COMPARISON
* Second Input Deck

********** Component Definitions **********

D1 VIN 0 D1
D2 VIN 0 D2
D3 VIN 0 D3

********** Model Definitions **********

.MODEL D1 D RS=1 IS=1E-14

.MODEL D2 D RS=1 IS=1E-13

.MODEL D3 D RS=1 IS=1E-12

********** NG-Spice Simulation Commands **********

.OPTIONS NOPAGE WIDTH=56
.PRINT TRAN V(VIN,0)
.TRAN 10.00m 100.00m 0.00m

.END
